Commit message: Added config files, gazebo launch

File: urdf/dalek.urdf (robot description, URDF)
Before this commit: robot dalek, 5 links, 4 joints
Joints:
- joint left_back_wheel_joint: type fixed -> continuous
- joint right_back_wheel_joint: type fixed -> continuous
